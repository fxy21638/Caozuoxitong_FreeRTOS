# Keil uVision project Fire_FreeRTOS.uvprojx, settings and files
target Fire_FreeRTOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Fire_FreeRTOS +hex
  c flags: Optim=3 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM4F;..\..\User\key;..\..\User\led;..\..\User\uart;..\..\User\exti;..\..\User\lcd;..\..\User\protocol;..\..\User\sdram;..\..\User\font;..\..\User\sensor;..\..\User\data;..\..\User\gui
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../User/: main.c stm32f4xx_it.c FreeRTOSConfig.h
  group BSP
    ../../User/led/: bsp_led.c
    ../../User/key/: bsp_key.c
    ../../User/uart/: bsp_debug_usart.c
    ../../User/lcd/: bsp_lcd.c bsp_lcd.h
    ../../User/sdram/: bsp_sdram.c bsp_sdram.h
    ../../User/font/: fonts.c fonts.h
  group PROTOCOL
    ../../User/protocol/: protocol.c protocol.h
  group DHT
    ../../User/sensor/dht/: bsp_dht.c bsp_dht.h
  group MPU6050
    ../../User/sensor/mpu6050/: bsp_mpu6050.c bsp_mpu6050.h bsp_mpu6050_i2c.c bsp_mpu6050_i2c.h dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h
  group FreeRTOS/src
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../../FreeRTOS/port/MemMang/: heap_4.c
    ../../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
  group DOC
    ../../: 必读说明.txt
